# Keil uVision project GD32H759I_START.uvprojx, settings and files
target GD32H7XX(USB_FS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.1.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: msc +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_USB_FS USE_USBHS0 GD32H7XX
  c include: ..\inc;..\..\..\..\GD32H7xx_Firmware_Library\CMSIS;..\..\..\..\GD32H7xx_Firmware_Library\CMSIS\GD\GD32H7xx\Include;..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_standard_peripheral\Include;..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_usbhs_library\driver\Include;..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_usbhs_library\device\core\Include;..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_usbhs_library\device\class\msc\Include;..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_usbhs_library\ustd\common;..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_usbhs_library\ustd\class\msc;..\..\..\Utilites
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application
    ../src/: app.c gd32h7xx_it.c gd32h7xx_usb_hw.c usbd_storage_msd.c flash_msd.c
  group CMSIS
    ../../../../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group GD32H7xx_Peripherals
    ../../../../GD32H7xx_Firmware_Library/GD32H7xx_standard_peripheral/Source/: gd32h7xx_ctc.c gd32h7xx_exti.c gd32h7xx_gpio.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_usart.c gd32h7xx_fmc.c
  group GD32H7xx_EVAL
    ../../../Utilites/: gd32h759i_start.c
  group Startup
    ../../../../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group USB_Driver
    ../../../../GD32H7xx_Firmware_Library/GD32H7xx_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../GD32H7xx_Firmware_Library/GD32H7xx_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../GD32H7xx_Firmware_Library/GD32H7xx_usbhs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group Doc
    ../: readme.txt
target GD32H7XX(USB_HS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.1.0
  cpu: as above
  output: cdc_acm +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_USB_HS USE_USBHS0 GD32H7XX
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
target GD32H7XX(USB_ULPI) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.1.0
  cpu: as above
  output: msc +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_USB_HS USE_USBHS1 GD32H7XX USE_ULPI_PHY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 5.4.0
