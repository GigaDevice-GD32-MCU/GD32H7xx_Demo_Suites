# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xI GD GD32H759xI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H7XX
  ICCARM.CCIncludePath2: ..\..\..\Third_party\lwip-2.1.2\src\include; ..\..\..\Third_party\lwip-2.1.2\src\include\ipv4; ..\..\..\Third_party\lwip-2.1.2\src\include\netif; ..\..\..\Third_party\lwip-2.1.2\src\include\lwip; ..\..\..\Third_party\lwip-2.1.2\port\GD32H7xx; ..\..\..\Third_party\lwip-2.1.2\port\GD32H7xx\FreeRTOS; ..\..\..\Third_party\lwip-2.1.2\port\GD32H7xx\arch; ..\..\..\Third_party\FreeRTOS-10.3.1\include; ..\..\..\Third_party\FreeRTOS-10.3.1\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_standard_peripheral\Include; ..\..\..\..\..\Utilites; ..\inc; ..\..\..\..\..\..\GD32H7xx_Firmware_Library\CMSIS\GD\GD32H7xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../src/: gd32h7xx_enet_eval.c gd32h7xx_it.c hello_gigadevice.c main.c netconf.c tcp_client.c udp_echo.c
  group CMSIS
    ../../../../../../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Doc
    ../: readme.txt
  group FreeRTOS
    ../../../Third_party/FreeRTOS-10.3.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Third_party/FreeRTOS-10.3.1/portable/MemMang/: heap_4.c
    ../../../Third_party/FreeRTOS-10.3.1/portable/IAR/ARM_CM4F/: port.c portasm.s
  group GD32H7xx_EVAL
    ../../../../../Utilites/: gd32h759i_eval.c
  group GD32H7xx_Peripherals
    ../../../../../../GD32H7xx_Firmware_Library/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group Lwip
    ../../../Third_party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../Third_party/lwip-2.1.2/src/netif/: ethernet.c
  group Lwip_port
    ../../../Third_party/lwip-2.1.2/port/GD32H7xx/FreeRTOS/: ethernetif.c sys_arch.c
  group Startup
    ../../../../../../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/IAR/: startup_gd32h7xx.s
