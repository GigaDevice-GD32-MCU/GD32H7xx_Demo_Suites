# IAR project GD32H757J_START.ewp, settings and files
configuration GD32H7xx_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32H757xM GD GD32H757xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H7XX; GD32H7XXI; USE_USB_FS; USE_USBHS0
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\GD32H7xx_Firmware_Library\CMSIS; ..\..\..\..\GD32H7xx_Firmware_Library\CMSIS\GD\GD32H7xx\Include; ..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_standard_peripheral\Include; ..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_usbhs_library\driver\Include; ..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_usbhs_library\device\core\Include; ..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_usbhs_library\device\class\msc\Include; ..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_usbhs_library\ustd\common; ..\..\..\..\GD32H7xx_Firmware_Library\GD32H7xx_usbhs_library\ustd\class\msc; ..\..\..\Utilites
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cdc_acm.srec
  ILINK.IlinkOutputFile: GD32H757J_START.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32H7xx_USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: GD32H7XX; GD32H7XXI; USE_USB_HS; USE_USBHS0
  group App
    ../src/: app.c flash_msd.c gd32h7xx_it.c gd32h7xx_usb_hw.c usbd_storage_msd.c
  group CMSIS
    ../../../../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Doc
    ../: readme.txt
  group GD32H7xx_Peripherals
    ../../../../GD32H7xx_Firmware_Library/GD32H7xx_standard_peripheral/Source/: gd32h7xx_ctc.c gd32h7xx_exti.c gd32h7xx_fmc.c gd32h7xx_gpio.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_usart.c
  group GD32H7xx_START
    ../../../Utilites/: gd32h757j_start.c
  group Startup
    ../../../../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/IAR/: startup_gd32h7xx.s
  group USB_Class
    ../../../../GD32H7xx_Firmware_Library/GD32H7xx_usbhs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group USB_Device
    ../../../../GD32H7xx_Firmware_Library/GD32H7xx_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../GD32H7xx_Firmware_Library/GD32H7xx_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
