<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GD32H757Z_START.ewp</path>
  </project>
  <batchBuild/>
</workspace>


